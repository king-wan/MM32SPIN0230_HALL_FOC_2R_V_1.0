# Keil uVision project MM32SPIN0230_Demo.uvprojx, settings and files
target MM32SPIN0230 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32SPIN0230B3TV MindMotion
  pack: MindMotion.MM32SPIN0230_DFP.1.1.2
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SPIN0230_DEMO +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_5V
  c include: ..\MM32SPIN0230\Include;..\MM32SPIN0230\HAL_Lib\inc;..\DRIVE\inc;..\SYSTEM\inc;..\USER\inc;..\M1_CONTROL\inc;..\MM_MCLIB\inc;..\MM_MCLIB\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ../USER/: main.c board.c mm32_it.c user_function.c
    ../USER/inc/: parameter.h
  group HAL_LIB
    ../MM32SPIN0230/HAL_Lib/src/: hal_adc.c hal_comp.c hal_dbg.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_hwdiv.c hal_iwdg.c hal_misc.c hal_opamp.c hal_pwr.c hal_rcc.c hal_syscfg.c hal_tim.c hal_uid.c hal_usart.c
  group Startup
    ../MM32SPIN0230/Source/: system_mm32spin0230.c
    ../MM32SPIN0230/Source/KEIL_StartAsm/: startup_mm32spin0230_keil.s
  group M1_CONTROL
    ../MM_MCLIB/: pwm_gen.c FOC_Math.c MC_Drive.c PID.c HallHandle.c Diagnose.c
  group DRIVE
    ../DRIVE/: drv_adc.c drv_comp.c drv_div.c drv_iwdg.c drv_led.c drv_opamp.c drv_pwm.c drv_tim.c
  group SYSTEM
    ../SYSTEM/: systick.c
software components: CMSIS:CORE 5.0.1
